# KOMPAS-3D part (ZARDP 080.080.40.P.m3d)

Model tree:
1. Операция без истории:1

Texts:
  ЗАРДП 080.080.40-ХХ.Р
  ООО "ИК Энерпред-Ярдос"